# Repository Cloud-Lightning/Hpm5e31_Core_Hardware

## KiCad design HPM5E31.kicad_pcb

Parts:
C8: 10uF; C_0603_1608Metric
C9: 1uF; C_0603_1608Metric
C10: 100nF; C_0603_1608Metric
C11, C12, C13, C14, C15: 22uF; C_0603_1608Metric
L1: 4.7uH; L_1008_2520Metric
R4: 0R; R_0603_1608Metric
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm

Connections:
+3.3V: C8.1, C10.1, U1.31 (DCDC_IN); also elsewhere on the board
+3.3VA: C9.1, R4.1; also elsewhere on the board
/HPM_DCDC/VREF: U1.39 (VREFH); also elsewhere on the board
GND: C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, U1.29 (DCDC_GND), U1.101 (PAD); also elsewhere on the board
GNDA: U1.38 (VSSA/VREFL); also elsewhere on the board
unnamed: C13.2, U1.71 (VDD_SOC)
unnamed: L1.2, U1.30 (DCDC_LP)
unnamed: C11.2, C12.2, C14.2, C15.2, L1.1, U1.4 (VDD_SOC), U1.32 (DCDC_SNS), U1.52 (VDD_SOC), U1.77 (VDD_SOC), U1.98 (VDD_SOC)
unnamed: R4.2, U1.37 (VANA)

Parts:
C41, C42, C45, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C70, C71, C72, C73, C75: 100nF; C_0603_1608Metric
C43, C44: 6pF; C_0603_1608Metric
C46, C47, C74: 10uF; C_0603_1608Metric
D5, D6, D7, D8: ESD9B3.3ST5G; D_SOD-323
FB2, FB3: FerriteBead; L_0603_1608Metric
J13: Conn_01x06_MountingPin; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
L2: 4.7uH; L_1008_2520Metric
R22, R23: 1.5K; R_0603_1608Metric
R24, R31, R36, R37, R38, R39, R40, R41, R43, R45, R46, R47, R48, R55, R56, R57, R58, R59, R60: 4.7K; R_0603_1608Metric
R25, R26, R27, R28, R29, R30, R33, R34, R35: 22R; R_0603_1608Metric
R32: 2.49K 1%; R_0603_1608Metric
R42, R44: 510R; R_0603_1608Metric
R63, R64, R65: 4.7K; R_0402_1005Metric
R69: 0R; R_0603_1608Metric
TP1, TP2, TP3: TestPoint; TestPoint_Pad_D1.0mm
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm
U6: RTL8211F-CG; MPN RTL8211F-CG
U7: 7*7*5-6P-L WX; 7_7_5-6P-L_WX_C2858287; LCSC Part C2858287
U8: HR911130A; HR911130A_C54408; LCSC Part C54408
Y3: X322525MOB4SI; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3.3V: C42.2, C71.2, FB3.2, R43.2, R45.2, R46.2, R47.2, R48.2, TP1.1 (1_1), U1.45 (VIO_B02); also elsewhere on the board
+5V: TP2.1 (1_1); also elsewhere on the board
/PIN_A/MDC: R22.2, R34.1; also elsewhere on the board
/PIN_A/MDIO: R23.2, R35.1; also elsewhere on the board
/PIN_BCD/MIDDLE: C57.1, R48.1, U7.5 (F1); also elsewhere on the board
/PIN_F/ADC0.IN00: J13.6, U1.40 (PF27/SDM0.CLK1/ADC0.IN00/ADC1.IN00/ACMP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)
/PIN_F/ADC0.IN01: J13.5, U1.50 (PF26/SDM0.DAT1/ADC0.IN01/ADC1.IN01/ACMP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)
/PIN_F/ADC0.IN02: J13.4, U1.44 (PF21/SDM0.DAT2/USB0.ID/ETH0.EVTI0/ESC0.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)
/PIN_F/ADC0.IN03: J13.3, U1.48 (PF20/SDM0.DAT3/USB0.OC/ETH0.EVTO1/ESC0.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)
/PIN_F/ADC1.IN08: J13.2, U1.47 (PF16/SDM0.DAT0/ADC0.IN08/ADC1.IN08/ACMP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)
/PIN_F/ADC1.IN10: J13.1, U1.41 (PF24/SDM0.DAT0/ADC0.IN10/ADC1.IN10/ACMP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)
/PIN_F/AVDD10: C46.2, C48.2, C50.2, FB2.2, U6.3 (AVDD10), U6.8 (AVDD10), U6.38 (AVDD10)
/PIN_F/CFG\LDO0/LED1: C75.2, R37.1, R42.2, R56.1, U6.33 (CFG_LDO0/LED1)
/PIN_F/CFG_EXT/LED0: R36.1, R55.1, U6.32 (CFG_EXT/LED0)
/PIN_F/CFG_LDO1/LED2: C74.2, R38.1, R44.2, R57.1, U6.34 (CFG_LDO1/LED2)
/PIN_F/CLKOUT: R33.1, U6.35 (CLKOUT)
/PIN_F/DOWN: C58.1, R47.1, U1.43 (PF23/SDM0.CLK3/USB0.OC/ADC0.IN15/ADC1.I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), U7.6 (F3)
/PIN_F/ETH0.RXCK: R25.1, R64.1, U1.59 (PF13/I2C1.SCL/MCAN3.STBY/ESC0.P1_RXCK/P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)
/PIN_F/ETH0.RXD0: R27.1, U1.62 (PF09/I2C0.SDA/MCAN2.RXD/ESC0.P1_RXD0/PW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)
/PIN_F/ETH0.RXD1: R28.1, U1.53 (PF10/MCAN2.STBY/ESC0.P1_RXD1/PWM1.P2/TR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)
/PIN_F/ETH0.RXD2: R29.1, U1.65 (PF11/ESC0.P1_RXD2/PWM1.P3/TRGM.P11/ETH0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)
/PIN_F/ETH0.RXD3: R30.1, R65.1, U1.60 (PF12/I2C1.SDA/ESC0.P1_RXD3/PWM1.P4/TRGM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)
/PIN_F/ETH0.RXDV: R26.1, R63.1, U1.64 (PF08/I2C0.SCL/MCAN2.TXD/ESC0.P1_RXDV/PW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)
/PIN_F/ETH0.TXCK: U1.57 (PF02/I2C2.SCL/MCAN0.STBY/ESC0.P1_TXCK/P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), U6.20 (TXC)
/PIN_F/ETH0.TXD0: U1.63 (PF03/I2C2.SDA/MCAN1.STBY/ESC0.P1_TXD0/P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), U6.18 (TXD0)
/PIN_F/ETH0.TXD1: U1.51 (PF04/MCAN1.RXD/ESC0.P1_TXD1/PWM0.P4/TRG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), U6.17 (TXD1)
/PIN_F/ETH0.TXD2: U1.56 (PF05/MCAN1.TXD/ESC0.P1_TXD2/PWM0.P5/TRG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), U6.16 (TXD2)
/PIN_F/ETH0.TXD3: U1.58 (PF06/I2C3.SDA/ESC0.P1_TXD3/PWM0.P6/TRGM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), U6.15 (TXD3)
/PIN_F/ETH0.TXEN: U1.61 (PF07/I2C3.SCL/ESC0.P1_TXEN/PWM0.P7/TRGM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), U6.19 (TXCTL)
/PIN_F/ETH_INT: R24.1, U1.54 (PF14/MCAN3.RXD/ESC0.P1_RXER/PWM1.P6/TRG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), U6.31 (INTB/PMEB)
/PIN_F/LEFT: C56.1, R46.1, U1.46 (PF22/SDM0.CLK2/USB0.ID/ETH0.EVTI1/ESC0.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), U7.4 (F5)
/PIN_F/MDIN0: D8.2 (A2), U6.2 (MDIN0), U8.P3 (MDI0-)
/PIN_F/MDIN1: D7.2 (A2), U6.5 (MDIN1), U8.P7 (MDI1-)
/PIN_F/MDIN2: D6.2 (A2), U6.7 (MDIN2), U8.P6 (MDI2-)
/PIN_F/MDIN3: D5.2 (A2), U6.10 (MDIN3), U8.P9 (MDI3-)
/PIN_F/MDIP0: D8.1 (A1), U6.1 (MDIP0), U8.P2 (MDI0+)
/PIN_F/MDIP1: D7.1 (A1), U6.4 (MDIP1), U8.P4 (MDI1+)
/PIN_F/MDIP2: D6.1 (A1), U6.6 (MDIP2), U8.P5 (MDI2+)
/PIN_F/MDIP3: D5.1 (A1), U6.9 (MDIP3), U8.P8 (MDI3+)
/PIN_F/PHYAD0/RXD3: R30.2, U6.22 (PHYAD0/RXD3)
/PIN_F/PHYAD1/RXC: R25.2, U6.27 (PHYAD1/RXC)
/PIN_F/PHYAD2/RXCTL: R26.2, U6.26 (PHYAD2/RXCTL)
/PIN_F/PHYRSTB: C41.2, R31.1, U6.12 (PHYRSTB); also elsewhere on the board
/PIN_F/PLLOFF/RXD2: R29.2, R39.1, R58.1, U6.23 (PLLOFF/RXD2)
/PIN_F/RIGHT: C54.1, R45.1, U1.49 (PF18/SDM0.DAT1/USB0.PWR/ETH0.EVTO0/ESC0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), U7.3 (F4)
/PIN_F/RSET: R32.1, U6.39 (RSET)
/PIN_F/RXDLY/RXD0: R27.2, R41.1, R60.1, U6.25 (RXDLY/RXD0)
/PIN_F/TXDLY/RXD1: R28.2, R40.1, R59.1, U6.24 (TXDLY/RXD1)
/PIN_F/UP: C55.1, R43.1, U1.42 (PF19/SDM0.CLK1/USB0.PWR/ADC0.IN13/ADC1.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), U7.1 (F2)
/PIN_F/VCC3V3_PHY: C70.2, C72.2, C73.2, FB3.1, R24.2, R31.2, R36.2, R37.2, R38.2, R64.2, R69.2, U6.11 (AVDD33), U6.29 (DVDD33), U6.40 (AVDD33)
/PIN_F/VCCIO_PHY: R22.1, R23.1, R39.2, R40.2, R41.2, R69.1, U6.28 (DVDD_RG)
/PIN_F/VDD1V0_PHY: C47.2, C49.2, C51.2, FB2.1, L2.2, U6.21 (DVDD10)
/PIN_F/XTAL\IN: C43.2, U6.36 (XTAL_IN), Y3.1
/PIN_F/XTAL_OUT/EXT_CLK: C44.2, U6.37 (XTAL_OUT/EXT_CLK), Y3.3
GND: C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.2, C55.2, C56.2, C57.2, C58.2, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, J13.MP (MountPin), R32.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R63.2, R65.2, TP3.1 (1_1), U6.41 (GND), U7.2 (Public), U7.7, U7.8, U8.12, U8.13, Y3.2 (G), Y3.4 (G); also elsewhere on the board
GNDPWR: U8.P10, U8.SHIELD0, U8.SHIELD1; also elsewhere on the board
unnamed: C45.2, R33.2
unnamed: C52.2, C53.2, U8.P1
unnamed: R42.1, U8.11
unnamed: R44.1, U8.14
unnamed: R34.2, U6.13 (MDC)
unnamed: R35.2, U6.14 (MDIO)
unnamed: L2.1, U6.30 (REG_OUT/LDO_OUT)

Notes on the sheet:
链路断开低功耗（ALDPS）模式 PLL 控制：上拉 = 进入 ALDPS 时关闭 PLL（极致低功耗），下拉 = 保持 PLL 运行 RGMII 接收时钟延迟控制：上拉 = 给 RXC 增加 2ns 内部延迟，下拉 = 无延迟 RGMII 发送时钟延迟控制：上拉 = 给 TXC 增加 2ns 内部延迟，下拉 = 无延迟
LED0 / CFG_EXT 上拉 = RGMII I/O 由外部电源供电 下拉 = RGMII I/O 由芯片内部 LDO 供电 - CFG_EXT=0（内部 LDO）：01=2.5V、10=1.8V、11=1.5V、00 = 保留 - CFG_EXT=1（外部电源）：00=3.3V、01=2.5V、10=1.8V、11=1.5V
PHY 地址配置 bit0，与 PHYAD1/PHYAD2 组合决定 MDIO 访问的 PHY 地址（支持 0x01~0x07）

Parts:
C17, C18: 6pF; C_0603_1608Metric
C19, C20, C21, C22, C23, C24, C26, C35, C36: 100nF; C_0603_1608Metric
C25, C27, C28, C29, C30: 10uF; C_0603_1608Metric
C31, C32, C33, C34: 22pF; C_0603_1608Metric
D1, D12, D13, D14: LED; LED_0603_1608Metric
D2: 1N4148W; D_SOD-123
FB1: FerriteBead; L_0603_1608Metric
J2: Conn_01x03_MountingPin; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
J3: RJ45_Hanrun_HR911105A_Horizontal
J15: Conn_01x03_Socket; Harwin_M20-89003xx_1x03_P2.54mm_Horizontal
Q1: SS8050; SOT-23
R5, R6, R7, R14, R15, R68: 10K; R_0603_1608Metric
R8: 12.1K 1%; R_0603_1608Metric
R9, R10, R11, R12: 49.9R; R_0603_1608Metric
R16, R17: 4.7K; R_0603_1608Metric
R18, R19: 510R; R_0603_1608Metric
R62: 10R; R_0603_1608Metric
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm
U2: LAN8720A; VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U3: HX JN1.27-2X6P ZZ H4.9; HX_JN1_27-2X6P_ZZ_H4_9_C42372548; LCSC Part C42372548
U4: MLT-5020; MLT-5020_C94598; LCSC Part C94598
Y2: X322525MOB4SI; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3.3V: C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C27.2, D2.1 (K), FB1.1, R62.1, U1.19 (VIO_B01), U1.55 (VIO_B01), U1.66 (VIO_B01), U1.72 (VIO_B01), U1.82 (VIO_B01), U1.99 (VIO_B01), U2.9 (VDDIO), U3.1, U4.1 (+); also elsewhere on the board
/PIN_A/AVDD: C28.2, C29.2, C30.2, C35.2, C36.2, FB1.2, J3.4 (TCT), J3.5 (RCT), R9.2, R10.2, R11.2, R12.2, U2.1 (VDD2A), U2.19 (VDD1A)
/PIN_A/BUZZER: R16.1, U1.7 (PA02/GPTMR1.COMP1/UART0.DE/UART0.RTS/I2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)
/PIN_A/CRS_DV/MODE2: U1.28 (PA16/GPTMR3.COMP0/UART4.TXD/ESC0.P0_RXD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), U2.11 (CRS_DV/MODE2)
/PIN_A/EMCODER_A: R14.1, U1.16 (PA28/UART7.CTS/SPI3.MISO/ESC0.P0_TXD3/E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)
/PIN_A/ENCODER_B: R68.1, U1.21 (PA20/UART5.CTS/SPI2.SCLK/ESC0.P0_RXD3/S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)
/PIN_A/ENCODER_KEY: R15.1, U1.25 (PA19/GPTMR3.CAPT1/UART4.CTS/SPI3.CS3/ES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)
/PIN_A/ESC0.P0_RXD0: U1.27 (PA17/GPTMR3.CAPT0/UART4.RXD/ESC0.P0_RXD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), U2.8 (RXD0/MODE0)
/PIN_A/ESC0.P0_RXD1: U1.26 (PA18/GPTMR3.COMP1/UART4.DE/UART4.RTS/ES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), U2.7 (RXD1/MODE1)
/PIN_A/ESC0.P0_RXER: R62.2, U1.15 (PA23/GPTMR2.COMP0/UART5.TXD/SPI2.MOSI/E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), U2.10 (RXER/PHYAD0)
/PIN_A/ESC0.P0_TXD0: U1.22 (PA25/GPTMR2.CAPT1/UART6.RXD/SPI3.CS1/ES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), U2.17 (TXD0)
/PIN_A/ESC0.P0_TXD1: U1.18 (PA26/GPTMR2.COMP2/UART6.DE/UART6.RTS/SP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), U2.18 (TXD1)
/PIN_A/ESC0.P0_TXEN: U1.14 (PA29/GPTMR3.COMP3/UART7.DE/UART7.RTS/SP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), U2.16 (TXEN)
/PIN_A/ESC0.REFCK: U1.24 (PA24/GPTMR2.COMP1/UART6.TXD/SPI3.CS2/ES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), U2.14 (~INT/REFCLKO)
/PIN_A/ESC_RST: U1.5 (PA09/GPTMR0.CAPT1/UART2.RXD/I2C0.SDA/MC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), U2.15 (~RST)
/PIN_A/GPTMR2.CAPT0: U1.10 (PA22/GPTMR2.CAPT0/UART5.RXD/SPI2.MISO/E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); also elsewhere on the board
/PIN_A/JTAG.TCK: U1.1 (PA06/GPTMR0.CAPT0/UART1.RXD/I2C3.SDA/SP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), U3.4
/PIN_A/JTAG.TDI: U1.2 (PA05/GPTMR1.COMP2/UART1.DE/UART1.RTS/SP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), U3.8
/PIN_A/JTAG.TDO: U1.3 (PA04/UART1.CTS/SPI1.SCLK/MCAN1.RXD/PWM0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), U3.6
/PIN_A/JTAG.TMS: U1.100 (PA07/GPTMR0.COMP0/UART1.TXD/I2C3.SCL/SP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), U3.2
/PIN_A/JTAG.TRST: U1.8 (PA08/GPTMR0.COMP1/UART2.TXD/I2C0.SCL/MC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), U3.10
/PIN_A/LED: R7.1, U1.6 (PA03/GPTMR1.CAPT1/UART0.CTS/I2C2.SDA/MC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)
/PIN_A/LED1/REGOFF: R5.2, R19.1, U2.3 (LED1/REGOFF)
/PIN_A/LED2/INTSEL: R6.2, R18.1, U2.2 (LED2/~INTSEL)
/PIN_A/MDC: U1.12 (PA31/GPTMR2.COMP3/UART7.TXD/SPI3.DAT3/E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), U2.13 (MDC); also elsewhere on the board
/PIN_A/MDIO: U1.13 (PA30/UART7.RXD/SPI3.DAT2/ESC0.MDIO/ETH0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), U2.12 (MDIO); also elsewhere on the board
/PIN_A/QEI1.F: U1.17 (PA27/UART6.CTS/SPI3.CS0/ESC0.P0_TXD2/QE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); also elsewhere on the board
/PIN_A/RXN: C34.2, J3.6 (RD-), R12.1, U2.22 (RXN)
/PIN_A/RXP: C33.2, J3.3 (RD+), R11.1, U2.23 (RXP)
/PIN_A/TXN: C32.2, J3.2 (TD-), R10.1, U2.20 (TXN)
/PIN_A/TXP: C31.2, J3.1 (TD+), R9.1, U2.21 (TXP)
/PIN_A/UART0.RXD: J2.2, J15.2, U1.9 (PA01/GPTMR1.CAPT0/UART0.RXD/MCAN0.RXD/P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), U3.12
/PIN_A/UART0.TXD: J2.3, J15.3, U1.11 (PA00/GPTMR1.COMP0/UART0.TXD/MCAN0.TXD/P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), U3.11
/PIN_A/VDDCR: C25.2, C26.2, U2.6 (VDDCR)
/PIN_A/XTAL1: C17.2, U2.5 (XTAL1/CLKIN), Y2.1
/PIN_A/XTAL2: C18.2, U2.4 (XTAL2), Y2.3
/PIN_F/PHYRSTB: U1.20 (PA21/GPTMR3.COMP2/UART5.DE/UART5.RTS/SP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); also elsewhere on the board
GND: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, D1.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), J2.1, J2.MP (MountPin), J3.10, J3.11, J15.1, Q1.2 (E), R5.1, R6.1, R8.2, R17.1, U2.25 (VSS), U3.3, U3.5, U3.7, U3.9, Y2.2 (G), Y2.4 (G); also elsewhere on the board
GNDPWR: J3.8, J3.SH; also elsewhere on the board
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), U4.2 (-)
unnamed: D12.2 (A), R14.2
unnamed: D13.2 (A), R15.2
unnamed: D14.2 (A), R68.2
unnamed: J3.9, R19.2
unnamed: J3.12, R18.2
unnamed: Q1.1 (B), R16.2, R17.2
unnamed: Q1.3 (C), U4.3 (NC)
unnamed: R8.1, U2.24 (RBIAS)

Parts:
C40: 100nF; C_0603_1608Metric
D3: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D9, D10: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J4, J12: Conn_01x04_MountingPin; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J5, J11: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_01x02_MountingPin; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J7, J8, J9, J10: Conn_01x06_MountingPin; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J16: Conn_01x04_Socket; Harwin_M20-89004xx_1x04_P2.54mm_Horizontal
Q2: SS8050; SOT-23
R20: 22R; R_0603_1608Metric
R21: 10R; R_0603_1608Metric
R61: 120R; R_0603_1608Metric
R66, R67: 3.3K; R_0603_1608Metric
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm
U5: TJA1051TK-3; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
U13: AFA11-S08GLA-00; AFC11-S08ICC-00_C262301; LCSC Part C2912855

Connections:
+3.3V: J4.1, J5.1, J7.6, J9.6, J10.6, J12.1, J16.1, R21.1, R67.1, U5.5 (VIO), U13.7; also elsewhere on the board
+5V: C40.1, D3.1 (VDD), J5.3, R66.1, U5.3 (VCC); also elsewhere on the board
/PIN_A/GPTMR2.CAPT0: J10.1; also elsewhere on the board
/PIN_A/QEI1.F: J10.2; also elsewhere on the board
/PIN_BCD/DC: J9.4, U1.97 (PB26/ESC0.CTR6/XPI0.CA_D2/QEI1.H1/SDM0.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), U13.4
/PIN_BCD/I2C3.SCL: J12.3, J16.3, U1.73 (PD07/I2C3.SCL/ESC0.GPI24/ESC0.GPO39/PPI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)
/PIN_BCD/I2C3.SDA: J12.4, J16.4, U1.74 (PD06/I2C3.SDA/ESC0.GPI25/ESC0.GPO38/PPI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)
/PIN_BCD/LEDA: Q2.2 (E), U13.1
/PIN_BCD/MCAN2.RXD: U1.90 (PC09/GPTMR0.CAPT1/UART2.RXD/I2C0.SDA/SP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), U5.4 (RXD)
/PIN_BCD/MCAN2.TXD: U1.91 (PC08/GPTMR0.COMP1/UART2.TXD/I2C0.SCL/SP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), U5.1 (TXD)
/PIN_BCD/MIDDLE: U1.94 (PB29/XPI0.CA_SCLK/QEI1.Z/SDM0.DAT1/ETH0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); also elsewhere on the board
/PIN_BCD/PWM0.P0: J8.6, U1.81 (PD00/MCAN0.TXD/ESC0.GPI31/ESC0.GPO32/PP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)
/PIN_BCD/PWM0.P1: J8.5, U1.80 (PD01/MCAN0.RXD/ESC0.GPI30/ESC0.GPO33/PP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)
/PIN_BCD/PWM0.P2: J8.4, U1.79 (PD02/I2C2.SCL/MCAN0.STBY/ESC0.GPI29/ESC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)
/PIN_BCD/PWM0.P3: J8.3, U1.78 (PD03/I2C2.SDA/MCAN1.STBY/ESC0.GPI28/ESC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)
/PIN_BCD/PWM0.P4: J8.2, U1.76 (PD04/MCAN1.RXD/ESC0.GPI27/ESC0.GPO36/PP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)
/PIN_BCD/PWM0.P5: J8.1, U1.75 (PD05/MCAN1.TXD/ESC0.GPI26/ESC0.GPO37/PP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)
/PIN_BCD/QEI1.A: J10.4, U1.93 (PB30/ESC0.CTR7/XPI0.CA_CS0/QEI1.A/SDM0.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)
/PIN_BCD/QEI1.B: J10.3, U1.92 (PB31/ESC0.CTR8/XPI0.CA_D3/QEI1.B/SDM0.D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)
/PIN_BCD/RES: J9.3, U1.96 (PB27/ESC0.CTR7/XPI0.CA_D0/QEI1.F/SDM0.D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), U13.3
/PIN_BCD/SPI1.CS0: J7.3, U1.88 (PC11/UART2.CTS/SPI1.CS0/ESC0.GPI52/ESC0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), U13.8
/PIN_BCD/SPI1.MISO: J7.2, U1.87 (PC12/UART3.CTS/I2C1.SDA/SPI1.MISO/ESC0.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)
/PIN_BCD/SPI1.MOSI: J7.1, U1.86 (PC13/GPTMR1.COMP3/UART3.DE/UART3.RTS/I2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), U13.5
/PIN_BCD/SPI1.SCLK: J7.4, U1.89 (PC10/GPTMR0.COMP2/UART2.DE/UART2.RTS/SP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), U13.6
/PIN_BCD/UART3.RXD: J4.4, U1.85 (PC14/UART3.RXD/SPI1.DAT2/MCAN3.RXD/ESC0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)
/PIN_BCD/UART3.TXD: J4.3, U1.84 (PC15/GPTMR0.COMP3/UART3.TXD/SPI1.DAT3/M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)
/PIN_BCD/W: J9.2, U1.95 (PB28/ESC0.CTR8/XPI0.CA_D1/QEI1.H0/SDM0.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)
GND: C40.2, D3.3 (VSS), D9.1 (K), D10.1 (K), J4.2, J4.MP (MountPin), J5.2, J6.MP (MountPin), J7.5, J7.MP (MountPin), J8.MP (MountPin), J9.5, J9.MP (MountPin), J10.5, J10.MP (MountPin), J12.2, J12.MP (MountPin), J16.2, U5.2 (GND), U5.8 (S), U5.9 (GND), U13.2, U13.9, U13.10; also elsewhere on the board
unnamed: D3.4 (DIN), J11.3
unnamed: D9.2 (A), R66.2
unnamed: D10.2 (A), R67.2
unnamed: J6.1, R61.2, U5.6 (CANL)
unnamed: J6.2, R61.1, U5.7 (CANH)
unnamed: J11.1, R20.1
unnamed: J11.2, U1.83 (PC16/GPTMR3.COMP0/UART4.TXD/ESC0.GPI47/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)
unnamed: Q2.1 (B), R20.2
unnamed: Q2.3 (C), R21.2

Parts:
C59, C62: 10uF; C_0603_1608Metric
C60, C61, C63, C64, C65, C67: 100nF; C_0603_1608Metric
C66: 10nF; C_0603_1608Metric
C68, C69: 22uF; C_0603_1608Metric
D4: SMF5V0A; D_SMF
F1: Fuse; Fuse_0603_1608Metric
J14: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
L3: 4.7uH; L_Changjiang_FTC252012S
R49, R50: 5.1K; R_0603_1608Metric
R51, R54: 0R; R_0603_1608Metric
R52: 30K; R_0603_1608Metric
R53: 10K; R_0603_1608Metric
U9: USBLC6-2SC6; SOT-23-6
U10: REF3033; SOT-23
U11: RY8411; MPN RY8411
U12: XC6210B332MR; SOT-23-5

Connections:
+3.3V: C68.1, C69.1, L3.2, R52.1; also elsewhere on the board
+3.3VA: C64.2, C65.2, C67.2, U12.5 (VOUT); also elsewhere on the board
+5V: C59.1, C60.2, C61.2, C62.1, D4.1 (A1), F1.2, U9.5 (VBUS), U10.1 (IN), U11.4 (EN), U11.5 (IN), U12.1 (VIN), U12.3 (CE); also elsewhere on the board
/Crystal/USB_DN: U9.6 (I/O1); also elsewhere on the board
/Crystal/USB_DP: U9.4 (I/O2); also elsewhere on the board
/HPM_DCDC/VREF: C66.2, R51.2; also elsewhere on the board
GND: C59.2, C60.1, C61.1, C62.2, C68.2, C69.2, D4.2 (A2), J14.A1 (GND), J14.A12 (GND), J14.B1 (GND), J14.B12 (GND), J14.S1 (SHIELD), R49.2, R50.2, R53.2, R54.1, U9.2 (GND), U11.2 (GND), U12.2 (GND); also elsewhere on the board
GNDA: C64.1, C65.1, C66.1, C67.1, R54.2, U10.3 (GND); also elsewhere on the board
unnamed: F1.1, J14.A4 (VBUS), J14.A9 (VBUS), J14.B4 (VBUS), J14.B9 (VBUS)
unnamed: J14.A5 (CC1), R49.1
unnamed: J14.B5 (CC2), R50.1
unnamed: J14.A6 (D+), J14.B6 (D+), U9.3 (I/O2)
unnamed: J14.A7 (D-), J14.B7 (D-), U9.1 (I/O1)
unnamed: R51.1, U10.2 (OUT)
unnamed: C63.1, U11.1 (BS)
unnamed: R52.2, R53.1, U11.3 (FB)
unnamed: C63.2, L3.1, U11.6 (SW)

Parts:
C1, C2: 10pF; C_0603_1608Metric
C3: 10uF; C_0603_1608Metric
C4, C5: 100nF; C_0603_1608Metric
C6, C7: 1uF; C_0603_1608Metric
R1: 1MR; R_0603_1608Metric
R2, R3: 10K; R_0603_1608Metric
SW1: SW_Push; SW_SPST_PTS810
U1: HPM5E31IPB1; LQFP-100_14x14mm_P0.5mm_EP6.0x6.0mm
Y1: 24Mhz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3.3V: C3.1, C4.1, R2.1, U1.33 (VPMC); also elsewhere on the board
/Crystal/USB_DN: U1.67 (USB0_DN); also elsewhere on the board
/Crystal/USB_DP: U1.68 (USB0_DP); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, R3.2, SW1.2, Y1.2 (G), Y1.4 (G); also elsewhere on the board
unnamed: C5.1, R2.2, SW1.1, U1.35 (RSTN)
unnamed: C6.2, U1.23 (VDD_OTPCAP)
unnamed: C7.1, U1.34 (VDD_PMCCAP)
unnamed: R3.1, U1.36 (WKUP)
unnamed: C1.1, R1.1, U1.69 (XTALI), Y1.1
unnamed: C2.1, R1.2, U1.70 (XTALO), Y1.3
